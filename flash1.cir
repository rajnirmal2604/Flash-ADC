* C:\Users\Public\flash1\flash1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/07/22 17:01:33

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ raj_priority_encoder
U3  Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ vout1 vout2 vout3 dac_bridge_3
scmode1  SKY130mode
v4  vref GND DC
X1  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC3-Pad1_ vin Net-_U2-Pad1_ GND avsd_opamp
X2  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC4-Pad1_ vin Net-_U2-Pad2_ GND avsd_opamp
X3  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC5-Pad1_ vin Net-_U2-Pad3_ GND avsd_opamp
X4  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC6-Pad1_ vin Net-_U2-Pad4_ GND avsd_opamp
X5  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC1-Pad2_ vin Net-_U2-Pad5_ GND avsd_opamp
X6  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC1-Pad1_ vin Net-_U2-Pad6_ GND avsd_opamp
X7  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC2-Pad1_ vin Net-_U2-Pad7_ GND avsd_opamp
X8  Net-_X1-Pad1_ Net-_X1-Pad2_ Net-_SC8-Pad1_ vin Net-_U2-Pad8_ GND avsd_opamp
v2  Net-_X1-Pad1_ GND DC
v3  Net-_X1-Pad2_ GND DC
SC3  Net-_SC3-Pad1_ vref ? sky130_fd_pr__res_generic_pd
SC4  Net-_SC4-Pad1_ Net-_SC3-Pad1_ ? sky130_fd_pr__res_generic_pd
SC5  Net-_SC5-Pad1_ Net-_SC4-Pad1_ ? sky130_fd_pr__res_generic_pd
SC6  Net-_SC6-Pad1_ Net-_SC5-Pad1_ ? sky130_fd_pr__res_generic_pd
SC7  Net-_SC1-Pad2_ Net-_SC6-Pad1_ ? sky130_fd_pr__res_generic_pd
SC1  Net-_SC1-Pad1_ Net-_SC1-Pad2_ ? sky130_fd_pr__res_generic_pd
SC2  Net-_SC2-Pad1_ Net-_SC1-Pad1_ ? sky130_fd_pr__res_generic_pd
SC8  Net-_SC8-Pad1_ Net-_SC2-Pad1_ ? sky130_fd_pr__res_generic_pd
U4  vout1 plot_v1
U5  vout2 plot_v1
U6  vout3 plot_v1
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U1-Pad8_ Net-_U1-Pad7_ Net-_U1-Pad6_ Net-_U1-Pad5_ Net-_U1-Pad4_ Net-_U1-Pad3_ Net-_U1-Pad2_ Net-_U1-Pad1_ adc_bridge_8
v1  vin GND DC

.end
